# IAR project Template_Isolation_XIP_FSBL.ewp, settings and files
configuration Template_Isolation_XIP_FSBL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 0
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx; NO_OTP_FUSE
  ICCARM.CCIncludePath2: ../../FSBL/Inc; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager; C:/Users/chira/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0/Drivers/STM32N6xx_HAL_Driver/Inc; C:/Users/chira/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0/Drivers/CMSIS/Device/ST/STM32N6xx/Include; C:/Users/chira/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0/Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; C:/Users/chira/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template_Isolation_XIP_FSBL.bin
  ILINK.IlinkOutputFile: Template_Isolation_XIP_FSBL.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx_fsbl.s
  group Application/User/FSBL
    ../../FSBL/Src/: extmem.c main.c stm32n6xx_it.c stm32n6xx_hal_msp.c
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    C:/Users/chira/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_xspi.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c
  group Doc
    ../../: README.md
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
  group Middlewares/STM32_ExtMem_Manager/boot
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot/: stm32_boot_xip.c
  group Middlewares/STM32_ExtMem_Manager/nor_sfdp
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
  group Middlewares/STM32_ExtMem_Manager/sal
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c
